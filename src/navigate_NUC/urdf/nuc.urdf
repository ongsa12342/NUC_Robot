Commit message: idk what is it but should work

File: src/navigate_NUC/urdf/nuc.urdf (robot description, URDF)
Before this commit: robot four_wheel_robot_with_lidar, 7 links, 6 joints
Joints:
- joint lidar_imu_joint: origin xyz=0 0 0.335 rpy=0 0 -0.2 -> xyz=0 0 0.335 rpy=0 0 -0.392
